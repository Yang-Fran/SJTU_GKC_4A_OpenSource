# Keil uVision project project0904.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NUC140VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: project0904
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;.\CMSIS\CM0\CoreSupport;.\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\Dependencies\Include;.\Dependencies\Include\Driver;.\Dependencies\Include\NUC1xx-LB_002;.\Dependencies\Src\Driver;.\Dependencies\Src\NUC1xx-LB_002;.\BoardSupport;.\COSTASProject
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./CMSIS/: startup_NUC1xx.s
    ./CMSIS/CM0/CoreSupport/: core_cm0.c
    ./CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Dependencies
    ./Dependencies/Src/Driver/: DrvADC.c DrvCAN.c DrvEBI.c DrvFMC.c DrvGPIO.c DrvI2C.c DrvI2S.c DrvPDMA.c DrvPS2.c DrvPWM.c DrvRTC.c DrvSPI.c DrvSYS.c DrvTIMER.c DrvUART.c retarget.c
    ./Dependencies/Src/NUC1xx-LB_002/: Ascii_Table.C DrvSDCard.c EEPROM_24LC64.c NAU7802.c Seven_Segment.c
  group BoardSupport
    ./BoardSupport/: AD9850_func.c adc_sample.c LCD_Driver_Modified.c Scan_6Key.c
  group Main
    ./COSTASProject/: app_state.c costas_loop.c main_source.c UIFUNC0728.c
